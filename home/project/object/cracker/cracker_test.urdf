Commit message: code and urdf update

File: home/project/object/cracker/cracker_test.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- removed link cheat_cracker_robot
- added link right_leg, mass 0; visual box size=0.16 0.21343700408935547 0.061
