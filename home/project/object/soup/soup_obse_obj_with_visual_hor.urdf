Commit message: code update

File: home/project/object/soup/soup_obse_obj_with_visual_hor.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: geometry visual cylinder length=0.1500 radius=0.033829689025878906
