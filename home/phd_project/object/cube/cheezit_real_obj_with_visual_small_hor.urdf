Commit message: code update

File: home/phd_project/object/cube/cheezit_real_obj_with_visual_small_hor.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link base_link: geometry visual box size=0.16 0.21343700408935547 0.062
