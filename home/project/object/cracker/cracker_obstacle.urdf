Commit message: code update

File: home/project/object/cracker/cracker_obstacle.urdf (robot description, URDF)
Before this commit: robot myfirst, 1 links, 0 joints
Links:
- link right_leg: geometry collision box size=0.1965 0.299 0.0711; visual box size=0.1965 0.299 0.0711
