Commit message: code update

File: home/project/object/soup/soup_par_with_visual_PB_hor.urdf (robot description, URDF)
Before this commit: robot object, 1 links, 0 joints
Links:
- link soup: geometry visual cylinder length=0.1000 radius=0.033829689025878906
